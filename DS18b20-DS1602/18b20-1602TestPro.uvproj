# Keil uVision project 18b20-1602TestPro.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 18b20-1602TestPro +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 DS18b20.C delay.c buzz.c DS1602.c main.c float_operations.c L298N.C
